/*
Florenc Caminade
Thomas FLayols

Send ESP-NOW vendor specific action frame example
https://hackaday.io/project/161896
https://github.com/thomasfla/Linux-ESPNOW

Adapted from : 
https://stackoverflow.com/questions/10824827/raw-sockets-communication-over-wifi-receiver-not-able-to-receive-packets

1/Find your wifi interface:
$ iwconfig

2/Setup your interface in monitor mode :
$ sudo ifconfig wlp5s0 down
$ sudo iwconfig wlp5s0 mode monitor
$ sudo ifconfig wlp5s0 up
$ sudo iwconfig wlp5s0 channel 11

3/Run this code as root
*/
#include <stdint.h>
#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include <unistd.h>
#include <sys/socket.h>
#include <sys/ioctl.h>
#include <linux/if_arp.h>
#include <arpa/inet.h>
#include <assert.h>

static uint8_t gu8a_dest_mac[6] = {0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF};

int create_raw_socket(char *dev)
{
	struct sockaddr_ll s_dest_addr; //code from sender
	struct ifreq ifr;
	int fd, ifi, rb;

	bzero(&s_dest_addr, sizeof(s_dest_addr));
	bzero(&ifr, sizeof(ifr));

	(void)memset(&s_dest_addr, 0, sizeof(s_dest_addr));

	fd = socket(PF_PACKET, SOCK_RAW, htons(ETH_P_ALL));
	assert(fd != -1); //abort if error

	strncpy((char *)ifr.ifr_name, dev, IFNAMSIZ);
	ifi = ioctl(fd, SIOCGIFINDEX, &ifr);
	assert(ifi != -1); //abort if error

	s_dest_addr.sll_family = PF_PACKET;
	//we don't use a protocol above ethernet layer, just use anything here
	s_dest_addr.sll_protocol = htons(ETH_P_ALL);
	s_dest_addr.sll_ifindex = ifr.ifr_ifindex;
	s_dest_addr.sll_hatype = ARPHRD_ETHER;
	s_dest_addr.sll_pkttype = PACKET_OTHERHOST; //PACKET_OUTGOING
	s_dest_addr.sll_halen = ETH_ALEN;
	//MAC - begin
	s_dest_addr.sll_addr[0] = gu8a_dest_mac[0];
	s_dest_addr.sll_addr[1] = gu8a_dest_mac[1];
	s_dest_addr.sll_addr[2] = gu8a_dest_mac[2];
	s_dest_addr.sll_addr[3] = gu8a_dest_mac[3];
	s_dest_addr.sll_addr[4] = gu8a_dest_mac[4];
	s_dest_addr.sll_addr[5] = gu8a_dest_mac[5];
	//MAC - end
	s_dest_addr.sll_addr[6] = 0x00; //not used
	s_dest_addr.sll_addr[7] = 0x00; //not used

	rb = bind(fd, (struct sockaddr *)&s_dest_addr, sizeof(s_dest_addr));
	assert(rb != -1); //abort if error

	return fd;
}

uint8_t data[] = {
0x00, 0x00, 0x18, 0x00, 0x2e, 0x40, 0x00, 0xa0, 0x20, 0x08, 0x00, 0x00, 0x00, 0x02, 0x6c, 0x09,
0xa0, 0x00, 0xdb, 0x00, 0x00, 0x00, 0xdb, 0x00, 0xd0, 0x00, 0x00, 0x00, 0xff, 0xff, 0xff, 0xff,
0xff, 0xff, 0x08, 0x3a, 0xf2, 0x50, 0xde, 0x5c, 0xff, 0xff, 0xff, 0xff, 0xff, 0xff, 0x00, 0x00,
0x7f, 0x18, 0xfe, 0x34, 0x18, 0xf4, 0x56, 0xa6, 0xdd, 0xff, 0x18, 0xfe, 0x34, 0x04, 0x01, 0x00,
0x00, 0x00, 0x00, 0xff, 0x7c, 0x94, 0xaa, 0x29, 0x23, 0xc9, 0xf2, 0x81, 0x83, 0x87, 0xa9, 0x9f,
0x7a, 0x23, 0x39, 0x78, 0x49, 0x35, 0x04, 0x48, 0xe8, 0x49, 0x43, 0x2a, 0xad, 0x5c, 0x79, 0xdd,
0x8a, 0x09, 0x6a, 0x0b, 0x2d, 0x7e, 0x3a, 0x50, 0x63, 0x15, 0xb3, 0xd8, 0x48, 0x0d, 0xd4, 0x19,
0xe5, 0xd1, 0x10, 0x7d, 0x78, 0x78, 0xe7, 0x49, 0x94, 0x3b, 0x7a, 0xf9, 0x95, 0xaa, 0xad, 0x40,
0xcc, 0xd1, 0xc4, 0x65, 0x37, 0x8e, 0x89, 0x9f, 0x16, 0x56, 0x31, 0x76, 0xde, 0xba, 0x41, 0xdc,
0x6e, 0xea, 0xc8, 0xb8, 0x8b, 0xc1, 0x07, 0x20, 0x3d, 0xce, 0x43, 0x8d, 0xab, 0xdd, 0x26, 0xef,
0xd7, 0x09, 0xe3, 0xbb, 0x6c, 0x07, 0x1c, 0x8b, 0x6f, 0x6e, 0xb1, 0xfd, 0xe1, 0xf1, 0x40, 0x21,
0xaf, 0x8d, 0xb6, 0xae, 0xfc, 0x7c, 0x92, 0x71, 0x63, 0x10, 0x96, 0xb0, 0x97, 0xe0, 0xa7, 0xa1,
0x23, 0xf5, 0x24, 0x45, 0x16, 0x12, 0x14, 0xe8, 0x0a, 0x4a, 0xe1, 0x25, 0x00, 0xce, 0x6b, 0xd6,
0x77, 0xba, 0xb4, 0xc1, 0xf3, 0x47, 0x51, 0xc6, 0x32, 0x5e, 0x15, 0xcb, 0xca, 0xf9, 0x77, 0xca,
0x19, 0x48, 0x8e, 0xcf, 0x93, 0x79, 0x9b, 0x9e, 0x8d, 0x0b, 0xb3, 0x4c, 0xcb, 0xe2, 0x14, 0x21,
0x1a, 0x22, 0x2c, 0x7a, 0x34, 0xd9, 0x07, 0x2b, 0xd6, 0x30, 0xe5, 0x04, 0x85, 0x42, 0x61, 0xd6,
0xea, 0x69, 0xd1, 0xe2, 0x21, 0xa9, 0x06, 0x9d, 0x67, 0xbb, 0xb7, 0x35, 0xd1, 0x52, 0xf0, 0x63,
0x9e, 0x8a, 0xaf, 0x28, 0xf7, 0x78, 0xbb, 0xe0, 0x0d, 0x87, 0x36, 0x73, 0x40, 0x8f, 0x7f, 0xde,
0x95, 0x57, 0x3b, 0x98, 0x0e, 0x63, 0x60, 0xb5, 0x5c, 0x59, 0xbd, 0x48, 0x14, 0x58, 0x99, 0x20,
0xd9, 0xf6, 0x5a, 0xb0, 0x18, 0x75, 0xe0, 0x76, 0xe7};

int main(int argc, char **argv)
{
	assert(argc == 2);
	int sock_fd = -1;
	char *dev = argv[1];

	sock_fd = create_raw_socket(dev); /* Creating the raw socket */
	if (sock_fd == -1) {
		perror("Could not create the socket");
		return 1;
	}

	printf("\nSending data using raw socket over %s\n", dev);

	while (1) {
		ssize_t res = sendto(sock_fd,data,sizeof(data),0,NULL,0);
		if (res == -1) {
			perror("Socket send failed");
			break;
		}
		int i = 0;
		for (i = 0; i < 331; i++)
			printf("%x ", data[i]);
		printf("\n\n");
		sleep(10);
	}

	close(sock_fd);
	return 0;
}
